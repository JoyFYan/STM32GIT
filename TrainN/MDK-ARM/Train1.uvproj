# Keil uVision project Train1.uvproj, settings and files
target Train1 Configuration (ARM-ADS)
  device: STM32F334C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Train1 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F334x8,ARM_MATH_CM4,__FPU_PRESENT = 1,__FPU_USED = 1
  c misc: --C99
  c include: ..\Inc; ..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
    ../Inc/: arm_cortexM4l_math.lib core_cm4.h arm_math.h
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_gpio.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_cortex.c stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc_ex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f334x8.s
  group Application/User
    ../Src/: stm32f3xx_it.c stm32f3xx_hal_msp.c main.c
